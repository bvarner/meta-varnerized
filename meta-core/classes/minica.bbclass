# Sets the root dir to use for minica when generating cert keys / pairs.
export MINICA_ROOT_DIR ?= '${TOPDIR}/gencert/'
export MINICA = "${STAGING_BINDIR_NATIVE}/minica"
