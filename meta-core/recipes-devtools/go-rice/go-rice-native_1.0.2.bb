include go-rice.inc

inherit native
