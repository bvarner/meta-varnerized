include go-rice.inc

inherit nativesdk
