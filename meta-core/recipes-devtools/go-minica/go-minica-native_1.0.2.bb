include go-minica.inc

inherit native
