include go-minica.inc

inherit nativesdk
